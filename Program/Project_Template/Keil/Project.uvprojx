# Keil uVision project Project.uvprojx, settings and files
target Target (6150000::V6.15::ARMCLANG)
  device: GD32F130C8 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.3.2.0
  cpu: IRAM(0x20000000,0x02000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Device\CMSIS;..\Device\CMSIS\GD\GD32F1x0\Include;..\Device\GD32F1x0_standard_peripheral\Include;..\BSP\Include;..\User\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group User
    ../User/Source/: main.c gd32f1x0_it.c systick.c
  group BSP
    ../BSP/Source/: bsp.c bsp_uart.c ring_buffer.c uio.c bsp_i2c.c bsp_spi.c sio.c
  group CMSIS
    ../Device/CMSIS/GD/GD32F1x0/Source/: system_gd32f1x0.c
    ../Device/CMSIS/GD/GD32F1x0/Source/ARM/: startup_gd32f1x0.s
  group Peripheral
    ../Device/GD32F1x0_standard_peripheral/Source/: gd32f1x0_adc.c gd32f1x0_can.c gd32f1x0_cec.c gd32f1x0_cmp.c gd32f1x0_crc.c gd32f1x0_dac.c gd32f1x0_dbg.c gd32f1x0_dma.c gd32f1x0_exti.c gd32f1x0_fmc.c gd32f1x0_fwdgt.c gd32f1x0_gpio.c gd32f1x0_i2c.c gd32f1x0_ivref.c gd32f1x0_misc.c gd32f1x0_opa.c gd32f1x0_pmu.c gd32f1x0_rcu.c gd32f1x0_rtc.c gd32f1x0_slcd.c gd32f1x0_spi.c gd32f1x0_syscfg.c gd32f1x0_timer.c gd32f1x0_tsi.c gd32f1x0_usart.c gd32f1x0_wwdgt.c
